# Keil uVision project Project.uvprojx, settings and files
target Porject (6220000::V6.22::ARMCLANG)
  device: PTM280x6x7 PengpaiMicroelectronics
  pack: PAI-IC.PT32x0xx_DFP.0.6.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c include: ..\..\..\Libraries\PT32x0xx_FWLib\src;..\..\..\Libraries\PT32x0xx_FWLib\inc;..\..\..\Libraries\CMSIS;..\..\..\Libraries\SYSTEM;..\..\..\Libraries\Retarget;..\..\Template
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group System
    ../../../Libraries/SYSTEM/PTM280x/: system_PTM280x.c
    ../../../Libraries/SYSTEM/PTM280x/arm/: startup_PTM280x.s
  group User
    ../: CMix_board.c CMix_control.c CMix_main.c CMix_pinmap.c CMix_i2c.c
  group Retarget
    ../../../Libraries/Retarget/: PT32x0xx_retarget.c
  group PT32x0xx_FWLib
    ../../../Libraries/PT32x0xx_FWLib/src/: PT32x0xx_adc.c PT32x0xx_cmp.c PT32x0xx_crc.c PT32x0xx_dma.c PT32x0xx_es.c PT32x0xx_exti.c PT32x0xx_gpio.c PT32x0xx_i2c.c PT32x0xx_ifmc.c PT32x0xx_iwdg.c PT32x0xx_ldac.c PT32x0xx_nvic.c PT32x0xx_opa.c PT32x0xx_pwr.c PT32x0xx_rcc.c PT32x0xx_spi.c PT32x0xx_syscfg.c PT32x0xx_tim.c PT32x0xx_uart.c
